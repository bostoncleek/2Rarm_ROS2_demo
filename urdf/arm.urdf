Commit message: IK working in rviz

File: urdf/arm.urdf (robot description, URDF)
Before this commit: robot two_link_arm, 4 links, 3 joints
Joints:
- joint end: origin xyz=${l2} 0 0 rpy=0 0 0 -> xyz=1.0 0 0 rpy=0 0 0
